# Keil uVision project FlyTest.uvprojx, settings and files
target FlyTest Configuration (ARM-ADS)
  device: STM32L476VGTx STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: FlyTest Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32l4xx_hal_msp.c gpio.c usart.c stm32l4xx_it.c main.c stm32l4xx_hal_msp.c gpio.c usart.c stm32l4xx_it.c main.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l476xx.s startup_stm32l476xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_i2c.c stm32l4xx_hal_cortex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_i2c.c stm32l4xx_hal_cortex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal.c stm32l4xx_hal_dma.c
software components: CMSIS:CORE 4.1.0
